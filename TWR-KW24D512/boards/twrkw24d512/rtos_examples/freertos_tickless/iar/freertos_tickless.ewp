# IAR project freertos_tickless.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 NXP MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW24D512VHA5; FSL_RTOS_FREE_RTOS; TWR_KW24D512; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM3; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../rtos/freertos_9.0.0/Source; ../../../../../devices/MKW24D5/drivers; ../../../../../devices/MKW24D5/utilities; ../../../../../devices/MKW24D5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: freertos_tickless.out
  ILINK.IlinkIcfFile: MKW24D512xxx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKW24D512VHA5; FSL_RTOS_FREE_RTOS; TWR_KW24D512; TOWER
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKW24D5/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM3/: fsl_tickless_generic.h fsl_tickless_lptmr.c fsl_tickless_systick.c port.c portasm.s portmacro.h
  group source
    ../: freertos_tickless.c FreeRTOSConfig.h
  group startup
    ../../../../../devices/MKW24D5/iar/: startup_MKW24D5.s
    ../../../../../devices/MKW24D5/: system_MKW24D5.c system_MKW24D5.h
  group utilities
    ../../../../../devices/MKW24D5/utilities/: fsl_debug_console.c fsl_debug_console.h
